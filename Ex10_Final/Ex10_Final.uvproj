# Keil uVision project Ex10_Final.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Ex10_Final
  c flags: Optim=1
  c define: _LCD_LANDSCAPE
  c include: ..\BSP\include;..\CMSIS\inc;..\Drivers\include;.\Source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../CMSIS/src/: startup_LPC17xx.s
  group Apps
    ./Source/: Always.c Date.c Home.c main.c More.c Other.c Time.c
  group CMSIS
    ../CMSIS/src/: core_cm3.c system_LPC17xx.c
  group BSP
    ../BSP/source/: BSP_Config.c joystick.c key.c LCD.c led.c
  group Drivers
    ../Drivers/source/: 24LC02.c command.c lpc1768_i2c.c lpc1768_rtc.c lpc1768_timer.c lpc1768_uart_polling.c monitor.c
